Commit message: changed the joint axis as z axis

File: Part_2/minimal_robot_description/minimal_robot_description_w_jnt_ctl.urdf (robot description, URDF)
Before this commit: robot one_DOF_robot, 3 links, 2 joints
Joints:
- joint joint1: axis 0 1 0 -> 0 0 1
